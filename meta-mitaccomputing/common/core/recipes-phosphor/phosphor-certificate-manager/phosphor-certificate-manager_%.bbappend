FILESEXTRAPATHS:prepend := "${THISDIR}/phosphor-certificate-manager:"

S = "${WORKDIR}/git"

SRC_URI += "file://0001-feat-Implement-ReNew-support-in-certificate-manager.patch \
            "

