# Walnascar: git sources unpack to ${UNPACKDIR}/git; default S=${UNPACKDIR}/${BP} is empty.
S = "${UNPACKDIR}/git"
